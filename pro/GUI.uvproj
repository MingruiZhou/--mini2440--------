# Keil uVision project GUI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: GUI
  AfterMake: fromelf.exe --bin -o bin/@p.bin out/@p.axf
  c flags: Optim=1
  c include: .\src;.\sys;.\src\inc;.\class
  asm include: .\sys;.\src;.\bmp
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x3000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group src
    ./src/: gui.c main.c gpio.c
  group sys
    ./sys/: IRQ.c MMU.c S3C2440.s uart.c clock.c LCD.c timer.c adc.c
  group font
    ./font/: font16x16.c zm16x16.c
  group class
    ./class/: element.c gameMng.c gameUi.c mat.c myUi.c share.c ui.c
  group element
    ./element/: element1.c element2.c element3.c element4.c element5.c element6.c element7.c element8.c element9.c element10.c element11.c element12.c
  group title
    ./title/: tit_exitGame.c tit_lian.c tit_seccess.c tit_start.c white.c tit_noConnect.c tit_timeOut.c tit_win.c
  group menu
    ./menu/: menu_back.c menu_block1.c menu_block2.c menu_block3.c menu_exit.c menu_g_back.c menu_next.c menu_restart.c menu_again.c menu_ok.c
